# Keil uVision project HeilsCar.uvproj, settings and files
target HeilsCar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HeilsCar +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Algorithm;..\Core;..\Driver;..\FWLib\inc;..\FWLib\src;..\Start;..\System;..\Task;..\Ucosii\Config;..\Ucosii\Core;..\Ucosii\Port;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Algorithm
    ../Algorithm/: _math.c _mecanum.c _pid.c _goline.c _gopath.c _keep.c _pathpoint.c _goroute.c _lcdio.c _serial.c _gps.c _diff.c
  group Driver
    ../Driver/: _24cxx.c _can.c _can_database.c _Command.c _ctiic.c _delay.c _io_status.c _lcd.c _myiic.c _ott2001a.c _ps2.c _pwm.c _tim.c _touch.c _uart.c _ultrasonic.c _encoder.c _ws2812b.c _adc.c
  group Task
    ../Task/: _task.c
    ../: IO资源.txt
  group System
    ../System/: sys.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group Core
    ../Core/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group UcosCore
    ../Ucosii/Core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UcosPort
    ../Ucosii/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
